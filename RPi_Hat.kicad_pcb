# Repository antonjan/Bacar_Raspberry_tx

File README.md:

This board is now compleet. Testing will start shortely.

This repository will have all the files for the PCB that fits on a Raspberry Pi witch will have a 7 stage low pass filter for the VHF 2m band. (About 60db down for first harmonic).<br>
<br>
It also now include a Mini Circuits low pass filter so you could use this board for two bands.
Operating manual will be available shortly.
This board is to be used with the rpitx utility to alow you to transmit on the 2m VHF band.
This board will have 7 stage lowpass filter.<br>
Here is the filter design details.<br>

<br>
Filter similator Diagram<br>

The PCB files is Kicad file format.<br>
The circuit diagram.<br>

PCB layout diagram during design

<br>
Chnaged Connectors transistor and regulator

<br>
PCB 3D view

Top SMA Connector is linkd to one filter.
Botom SMA connector is connected to 7 stage filter.
<br>
3DB RF Attenuator T (Kicad)

<br>
6dB Rf attenuator T (Kicad)

<br>
9dB Rf attenuator T (Kicad)

<br>
PCB wave guide with Ground plane impedance calculator 50ohm (Kicad)

<br>

## KiCad design RPi_Hat.kicad_pcb

Parts:
C1: 10nf; C_0805_HandSoldering
C2: 1uF; c_elec_4x5.7
C3: 47uF; c_elec_6.3x5.7
C4, C6: 33pF; C_0805_HandSoldering
C5: 36pF; C_0805_HandSoldering
D1: LED; LED-3MM
J3: RPi_GPIO; Pin_Header_Straight_2x20
L1, L4: 56nH; C_0805_HandSoldering
L2, L3: 110nH; C_0805_HandSoldering
P1: 3Sip100; Pin_Header_Straight_1x03
P2: 4Sip200; TerminalBlock_Pheonix_MKDS1.5-4pol
P3: 2Sip200; TerminalBlock_Pheonix_MKDS1.5-2pol
P4: SMA; SMA_Edge
P5: CONN_01X02; Pin_Header_Straight_1x02
Q1: BC817-40; SOT-23
R1: 4k7; R_0805_HandSoldering
R2, R4, R5, R6, R8: 0; R_0805_HandSoldering
R3, R7: oc; R_0805_HandSoldering
R9: 250; R_0805_HandSoldering
U1: L4940V5 1.5A; TO-220

Connections:
+3V3: J3.1 (3.3V), J3.17 (3.3V), P2.1
+5V: C2.1, D1.2 (A), J3.2 (5V), J3.4 (5V), P2.2, U1.3
GND: C2.2, C3.2, C4.2, C5.2, C6.2, J3.6 (GND), J3.9 (GND), J3.14 (GND), J3.20 (GND), J3.25 (GND), J3.30 (GND), J3.34 (GND), J3.39 (GND), P2.4, P3.2, P4.2, Q1.2, R3.2, R7.2, R9.2, U1.2
unnamed: C1.1, R2.2
unnamed: C1.2, P1.2
unnamed: C3.1, P3.1, U1.1
unnamed: C4.1, L1.2, L2.1
unnamed: C5.1, L2.2, L3.1
unnamed: C6.1, L3.2, L4.2
unnamed: D1.1 (K), R9.1
unnamed: J3.3 (GPIO02_SDA1_I2C), P5.2
unnamed: J3.5 (GPIO03_SCL1_I2C), P5.1
unnamed: J3.7 (GPIO04_GCLK), P1.1
unnamed: J3.8 (GPIO14_TXD0), P1.3
unnamed: J3.12 (GPIO18), R1.2
unnamed: L1.1, R5.1
unnamed: L4.1, R6.2
unnamed: P2.3, R4.1
unnamed: P4.1, R8.1
unnamed: Q1.1, R1.1
unnamed: Q1.3, R4.2
unnamed: R2.1, R3.1, R5.2
unnamed: R6.1, R7.1, R8.2

Notes on the sheet:
Atuniator

Board: 2 copper layers, 66.0 x 56.5 mm, 28 parts (0 on the bottom side), 23 nets.

## Commit log

2017-01-15 Loading the first diagrams
2017-01-15 First discription
2017-01-15 Loading filter Design diagrams
2017-01-17 added annotation and module details
    sma connector footprint still not corect
2017-01-17 added details about kikad
2017-01-18 Created SMA footprint and started laying out board
2017-01-18 Added SMA Module
2017-01-18 Added filter digram link
2017-01-18 Added Filter similator diagram
2017-01-18 Added Picture of circuit diagram
    Added Picture of circuit diagram if you don't have Kicad
2017-01-18 added circuit diagram
2017-01-18 PCB layout diagram
2017-01-18 Added PCB Diagram
2017-01-19 Placing components
2017-01-25 Change Regulator transistor and connectors
    Change Regulator transistor and connectors
    Started laying out PCB
2017-01-25 change formating
2017-01-31 Added updated pcb
2017-01-31 reverted to previous readme
2017-01-31 Added status update
2017-02-02 Low pass filter data
2017-02-02 Finished PCB but still need to do DRC
    Almost complete
    Still need to DRC and component check
2017-02-02 added the To Do
2017-02-02 Added 3D View of PCB
2017-02-02 added 3d diagram
2017-02-03 Board is now Compleet
    Added second filter
2017-02-03 Board is now compleate
    Added second filter
2017-02-15 Added license
2017-02-15 updated project status
2017-02-15 Added more details
2017-02-15 Added 3d view of dual filter board
2017-02-15 updated 3d Diagram
2017-02-15 added updated dual filter Diagram
2017-02-15 Added new Diagram
2017-02-15 Added Comments to 3d Diagram
2017-02-16 adding Rf Attenuator and wave guide details
2017-02-16 Added link to Rf Attenuator
2017-02-16 Added Wave guide details
2017-02-16 fixed formating
2017-02-16 added 9db attenuator
2017-02-22 Added picture
2017-02-22 Added details
2017-02-22 Added picure
2017-04-03 Adding pdf Diagram
2019-05-04 add from
    https://jacobzelek.com/posts/2016-04-24-raspberry-pi-sdr/
